Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2024-01-28T23:50:43
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20200210_1400(x64) - Exporter 20.2.12.1 - Alternate UI 20.2.12.1
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Sun Jan 28 23:50:43 2024 * Host: DESKTOP-13TP49N * Database: C:\Users\andre\AppData\Local\Temp\8f60cd24-d351-4d47-92a9-e92f049f2c17\feed9c3d-6344-4cdb-88d8-7aa7cc2f899d\ifc * Database version: 5507 * Database creation date: Sun Jan 28 23:50:42 2024 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Sun Jan 28 23:50:43 2024 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Sun Jan 28 23:50:43 2024 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Other - Category: Project Information

# IfcBuilding
Other - Category: Project Information

# IfcBuildingStorey: Level:Level 1, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: Level 1; Family and Type: Level: Level 1; Type: Level: Level 1; Type Id: Level: Level 1
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Level 1

# IfcDistributionPort (2)
Description: Flow; FlowDirection: SOURCE

# IfcFlowController: 01556269 Washbasin faucet, Bluetooth, 01556269(2023):01556269 Washbasin faucet, Bluetooth:53599
In: Level 1
Type - PredefinedType: FAUCET; Material: Brass
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - NominalDepth: 189.104 mm; NominalHeight: 100.184 mm; NominalWidth: 289 mm
Type - Electrical - Bluetooth: 5.x (D060576); Operating Voltage: 0 V; Protection Class: IP 55
Type - General - Author: BIMStone; BIMObjectName: 01556269(2023); ManufacturerName: HANSA; ManufacturerURL: http://www.hansa.com; NBSDescription: Water supply fittings for wash basins and troughs; NBSReference: 45-35-70/371; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_30_96_96; Uniclass2015Description: Washbasin manual water supply sets; Uniclass2015Reference: Pr_40_20_87_96; Version: 1; VersionDate: 17/01/2024
Type - Green Building Properties - EAN Number: 4057304020506; EMC Directive: Radio Equipment Directive 2014/53/EU , Low Voltage Directive 2014/35/EU , EMC Directive 2014/30/EU , RoHS Directive 2011/65/EU; Sales Package dimensions (LxWxH): 278 x 218 x 202; URL Declaration of Asbestos: http://static.hansa.com/doc/asbestos; URL Declaration of Conformity: http://static.hansa.com/DoC/01556269; URL Declaration Of Performance (DOP): http://static.hansa.com/doc/DoP; URL Declaration of SCIP: http://static.hansa.com/doc/SCIP; URL EcoLabel Declaration: http://static.hansa.com/doc/EcoLabel; URL EU Packaging Declaration: http://static.hansa.com/doc/packaging; URL REACH: http://static.hansa.com/doc/reach; URL WEEE: http://static.hansa.com/WEEE/01556269
Type - Identity Data - 2D/3D/BIM Files URL: http://static.hansa.com/bim/01556269; 3D View: https://static.hansa.com/AR/01556269; Catalog Drawing URL: http://static.hansa.com/catdrw/01556269; Dimension Drawing URL: http://static.hansa.com/dimdrw/01556269; FDV Document URL: http://www.hansa.com/datasheet/01556269/en/fdv; Group: Washbasin faucet; Installation and Maintenance Guide URL: http://static.hansa.com/manual/01556269; Interactive AR View URL: https://static.hansa.com/AR/01556269; Manufacturer: HANSA; Market: International;Germany;Austria;Belgium;Netherlands; Mobile Product Information URL: http://mpi.hansa.com/01556269; Model: 01556269 Washbasin faucet, Bluetooth; Name_en: 01556269 Washbasin faucet, Bluetooth; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Product Code: 01556269; Product Family: HANSACLINICA Digital+; Product Image URL: http://static.hansa.com/image/01556269; Product URL: http://static.hansa.com/01556269; Short Marketing: This faucet is designed for Health care usage. With its Low lead water ways and a well designed body that is easy to clean while the long lever makes it easy and intuitive to operate. With our latest technology it is possible to connect this faucet to the Digital water management service. The online service helps monitoring of the usage to prevent stagnation and to follow-up the temperatures in the piping. Measuring technology inside the faucet body is self-powered by water, no batteries needed. Clever design with a world of information inside.; Technical DataSheet URL: http://www.hansa.com/datasheet/01556269/en; Type Name: 01556269 Washbasin faucet, Bluetooth; Warranty Information URL: http://warranty.hansa.com
Type - Materials and Finishes - FaucetMainMaterial: Brass
Type - Mechanical - Advanced Features: Composite; Aerator: Laminar stream; Connection: Eccentric coupling(s); Installation Type: Wall mounted; Lever Handle: Loop shape; Mechanical Parts: ø 40 mm ceramic cartridge for flow and temperature control; Surface treatment: Chrome
Type - Other - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; Brand: HANSA; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 01556269(2023); Features: Single-lever;Self-powered;Bluetooth®;Lead free; Finish: Polished; Grade: n/a; ModelNumber: n/a; ModelReference: 01556269; Name: 01556269 Washbasin faucet, Bluetooth; ReplacementCost: n/a; Shape: Sculptured; Size: 220 x 240 x 180 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.hansa.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Constraints - DefaultElevation: 895.312 mm; Elevation from Level: 0 mm; Host: Level : Level 1; Level: Level: Level 1; Offset from Host: 0 mm
Dimensions - Area: 0.0994641 m2; ConnectorDirection: 0; ConnectorDirectionNote: 0-Up II 1-Back II 2-Down; InletConnectionSize: 15 mm; InletDistance: 150 mm; OutletAngle: 0 deg; Volume: 0.00582653 m3
Identity Data - Mark: 24
Mechanical - System Classification: Domestic Hot Water,Domestic Cold Water
Other - AssetIdentifier: n/a; Barcode: n/a; Family: 01556269(2023): 01556269 Washbasin faucet, Bluetooth; Family and Type: 01556269(2023): 01556269 Washbasin faucet, Bluetooth; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 01556269(2023): 01556269 Washbasin faucet, Bluetooth; Type Id: 01556269(2023): 01556269 Washbasin faucet, Bluetooth; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
